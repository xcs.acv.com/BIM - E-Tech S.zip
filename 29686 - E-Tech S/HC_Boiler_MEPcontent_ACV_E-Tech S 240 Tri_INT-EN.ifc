Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2021-05-25T14:42:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue May 25 14:42:40 2021 * Host: RVIDREA-RO-LE * Database: C:\Users\RVidrea\AppData\Local\Temp\{75A55857-B2C7-47D5-AB7C-B9C3E07344E5}\ifc * Database version: 5507 * Database creation date: Tue May 25 14:42:39 2021 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Tue May 25 14:42:39 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue May 25 14:42:39 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: Floor Level
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: V00; Structural: no
Other - Category: Levels; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Constraints(Type) - Elevation Base: Project Base Point

# IfcBoiler: E-Tech S 240 Tri, HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN:E-Tech S 240 Tri:1303865
In: V00
Type - PredefinedType: WATER; Material: Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 040-040-040, Color RGB 073-073-073, Color RGB 002-128-024, Color RGB 143-146-144
Type - Dimensions - Depth: 728 mm; Domestic Connector Diameter: 19.05 mm; Drain Diameter: 12.7 mm; Height: 1818 mm; Hydronic Return Diameter: 25.4 mm; Hydronic Supply Diameter: 25.4 mm; Use Nominal Diameter: yes; Width: 590 mm
Type - Electrical - Frequency: 50 Hz; Max Power Boiler: 28800 W; Phase: 3; Power Resistance (kW): 28.8; Voltage: 400 V
Type - Identity Data - Article Type: E-Tech S 240 Tri; Base Family Version: 12.27; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Compact floor standing combination electric boiler. Flexible installation options; EMCS Version: 4.0; ETIM Article Class: EC010082; Family Version: 12.27; GLN: 5400891000007; Manufacturer: ACV; Manufacturer URL: https://www.acv.com/international/customer/dl/3677; MEPcontent Class: BOILER; Model: E-Tech S 240 Tri; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Revit Version: 2018; Type Name: E-Tech S 240 Tri; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Dark Grey: Color RGB 073-073-073; Green: Color RGB 002-128-024; Light Grey: Color RGB 143-146-144; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - Maximum Supply Temperature (Operating Temperature): 85 kg/K/s3; Max Pressure DHW: 1000000 Pa; Max Pressure Heating: 300000 Pa; Total Capacity: 0.25 m3; Weight: 155
Type - Other - Category: Mechanical Equipment; C: 1100 mm; Connector Height: 1645 mm; Domestic Connection: 20 mm; Family Name: HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN; Hydronic Supply Length: 1610 mm; Nominal Diameter: 25.4 mm; Outer Diameter: 33.7 mm; Profile: XL; Space Heating Energy Efficiency Class: D; Upper Connection Height: 1610 mm; Water Heating Energy Efficiency Class: C
Type - Text - Article Description: Compact floor standing combination electric boiler. Flexible installation options; GTIN: 5400891032404; Manufacturer Art. No.: A1002086; Pipe Type Category: M561; Product Line: E-Tech S
Pset_ManufacturerTypeInformation - Manufacturer: ACV
Constraints - Offset: 0 mm
Dimensions - Area: 9.1318 m2; Volume: 0.611762 m3
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Drain Fixture Units: 0; Hydronic Return Flow: 0 m3/s; Hydronic Supply Flow: 0 m3/s; System Classification: Hydronic Supply,Hydronic Return,Domestic Hot Water,Domestic Cold Water,Sanitary,Power
Other - Back Clearance: 150 mm; Connection Height: 1610 mm; Connector Angle: 90 deg; Connector Length 1: 195 mm; Connector Length 2: 296.4 mm; Family: HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN: E-Tech S 240 Tri; Family and Type: HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN: E-Tech S 240 Tri; Front Clearance: 500 mm; Left Clearance: 0 mm; Reference Line Length: 100 mm; Right Clearance: 0 mm; Top Clearance: 300 mm; Type: HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN: E-Tech S 240 Tri; Type Id: HC_Boiler_MEPcontent_ACV_E-Tech S_160-240_INT-EN: E-Tech S 240 Tri
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Back Connection: yes; Left Connection: no; Right Connection: no; Service Space: no
